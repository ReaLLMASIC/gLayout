** sch_path: blocks/composite/folded_cascode/designs/gf180/error_amplifier_core_N_input/cace/templates/ac.sch
**.subckt ac
V5 Vn Vx AC 1
C2 Vx Vin 10G m=1
L4 Vy Vx 10G m=1
C1 Vout GND 5p m=1
* noconn Vcom
V1 VbiasP2 GND CACE{VbiasP2}
V2 VbiasN2 GND CACE{VbiasN2}
V3 VbiasN1 GND CACE{VbiasN1}
V4 VDD GND CACE{VDD}
V6 VSS GND 0
V8 VbiasP1 GND CACE{VbiasP1}
V7 Vin GND CACE{Vin_CM}
V9 Vz Vy CACE{Vy}
E1 Vz GND Vout GND 1
E2 Vaa GND VbiasP1 GND 1
R1 Vaa GND 1k m=1
x1 VbiasP1 VbiasP2 VbiasN2 Vout Vin Vn VDD VSS Vcom error_amplifier_core_N_input
**** begin user architecture code


.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/sm141064.ngspice CACE{corner}

.include CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/design.ngspice
.include CACE{DUT_path}

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1






    *remzerovec
    *write error_amplifier_core_N_input_ac.raw
    *set appendwrite


.control
save all

*DC simulation
op
* run ac simulation
ac dec 20 1 100e7


* measure parameters
let vout_mag = db(abs(v(Vout)))
*let vout_phase = cph(v(Vout)) * (180/pi)
let vout_phase = cph(v(Vout)) * (57.295779513)
let gm = (-1)*db(abs(v(Vout)))

meas ac A0 find vout_mag at=1
meas ac UGB when vout_mag=0 fall=1
meas ac PM find vout_phase when vout_mag=0
meas ac GM find gm when vout_phase=0

let A0_p1 = A0 - 3
meas ac BW when vout_mag=A0_p1

print A0 UGB PM GM BW
echo $&A0 $&UGB $&PM $&GM $&BW > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc


**** end user architecture code
**.ends

* expanding   symbol:  error_amplifier_core_N_input.sym # of pins=9
** sym_path: blocks/composite/folded_cascode/designs/gf180/error_amplifier_core_N_input/xschem/error_amplifier_core_N_input.sym
** sch_path: blocks/composite/folded_cascode/designs/gf180/error_amplifier_core_N_input/xschem/error_amplifier_core_N_input.sch
.subckt error_amplifier_core_N_input VbiasP2 VbiasN2 VbiasN1 Vout V+ V- VDD VSS Vcomn
*.ipin VbiasN2
*.iopin VDD
*.ipin VbiasP2
*.ipin VbiasN1
*.ipin V+
*.ipin V-
*.iopin VSS
*.iopin Vcomn
*.iopin Vout
XM4 Vdm6 Val VDD VDD pfet_03v3 L=0.3u W=4u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) *
+ W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=12
XM3 Vdm5 Val VDD VDD pfet_03v3 L=0.3u W=4u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) *
+ W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=12
XM5 Val VbiasP2 Vdm5 VDD pfet_03v3 L=2u W=6u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=2
XM6 Vout VbiasP2 Vdm6 VDD pfet_03v3 L=2u W=6u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=2
XM9 net1 VbiasN1 VSS VSS nfet_03v3 L=2u W=2u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=2
XM8 Vout VbiasN2 Vcomn VSS nfet_03v3 L=2u W=5u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=1
XM7 Val VbiasN2 net1 VSS nfet_03v3 L=2u W=5u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=1
XM10 Vcomn VbiasN1 VSS VSS nfet_03v3 L=2u W=2u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=2
XM15 VDD VDD VDD VDD pfet_03v3 L=3u W=1u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf
+ * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u
+ / W' sa=0 sb=0 sd=0 m=28
XM16 VDD VDD VDD VDD pfet_03v3 L=1.5u W=1u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) *
+ W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=20
XM13 VSS VSS VSS VSS nfet_03v3 L=3u W=1u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf
+ * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u
+ / W' sa=0 sb=0 sd=0 m=18
XM12 VSS VSS VSS VSS nfet_03v3 L=6.5u W=0.5u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=36
XM14 VSS VSS VSS VSS nfet_03v3 L=1u W=1u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf
+ * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u
+ / W' sa=0 sb=0 sd=0 m=30
XM1 Vdm6 V- net2 VSS nfet_03v3 L=1u W=10u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) *
+ W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=20
XM2 Vdm5 V+ net2 VSS nfet_03v3 L=1u W=10u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) *
+ W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=20
XM11 net2 VbiasN1 VSS VSS nfet_03v3 L=2u W=2u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=40
.ends

.GLOBAL GND
.end
