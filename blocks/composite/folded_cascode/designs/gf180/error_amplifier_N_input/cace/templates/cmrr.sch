** sch_path: blocks/composite/folded_cascode/designs/gf180/error_amplifier_N_input/cace/templates/cmrr.sch
**.subckt cmrr
V5 V+ Vref AC 1
C3 V- V+ 10G m=1
L2 Vout V- 10G m=1
* noconn #net1
C4 Vout GND 5p m=1
V8 VDD GND CACE{vdd}
V9 VSS GND 0
x1 Vout V+ V- Vref VDD VSS net1 error_amplifier_N_input
V1 Vref GND CACE{vref}
**** begin user architecture code


.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/sm141064.ngspice CACE{corner}

.include CACE{PDK_ROOT}/CACE{PDK}/libs.tech/ngspice/design.ngspice
.include CACE{DUT_path}

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1






.control
save all

** OP simulation
op

** run ac simulation
ac dec 20 1 100e6

setplot ac1

* measure parameters
let vout_mag = db(abs(v(Vout)))
let vout_phase = cph(v(Vout)) * 180/pi

meas ac Acm find vout_mag at=1

*plot vout_mag vout_phase

print Acm
echo $&Acm > CACE{simpath}/CACE{filename}_CACE{N}.data


.endc


**** end user architecture code
**.ends

* expanding   symbol:  error_amplifier_N_input.sym # of pins=7
** sym_path: blocks/composite/folded_cascode/designs/gf180/error_amplifier_N_input/xschem/error_amplifier_N_input.sym
** sch_path: blocks/composite/folded_cascode/designs/gf180/error_amplifier_N_input/xschem/error_amplifier_N_input.sch
.subckt error_amplifier_N_input Vout V+ V- Vref VDD VSS Vcomn
*.ipin V+
*.iopin Vout
*.ipin V-
*.ipin Vref
*.iopin VDD
*.iopin VSS
*.iopin Vcomn
x1 VbiasP2 VbiasN2 VbiasN1 Vout V+ V- VDD VSS Vcomn error_amplifier_core_N_input
x2 VbiasN1 VbiasN2 VbiasP2 VDD VSS Vref net1 error_amplifier_bias_N_input
* noconn #net1
.ends


* expanding   symbol:  error_amplifier_core_N_input.sym # of pins=9
** sym_path: blocks/composite/folded_cascode/designs/gf180/error_amplifier_core_N_input/xschem/error_amplifier_core_N_input.sym
** sch_path: blocks/composite/folded_cascode/designs/gf180/error_amplifier_core_N_input/xschem/error_amplifier_core_N_input.sch
.subckt error_amplifier_core_N_input VbiasP2 VbiasN2 VbiasN1 Vout V+ V- VDD VSS Vcomn
*.ipin VbiasN2
*.iopin VDD
*.ipin VbiasP2
*.ipin VbiasN1
*.ipin V+
*.ipin V-
*.iopin VSS
*.iopin Vcomn
*.iopin Vout
XM4 Vdm6 Val VDD VDD pfet_03v3 L=0.3u W=4u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) *
+ W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=12
XM3 Vdm5 Val VDD VDD pfet_03v3 L=0.3u W=4u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) *
+ W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=12
XM5 Val VbiasP2 Vdm5 VDD pfet_03v3 L=2u W=6u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=2
XM6 Vout VbiasP2 Vdm6 VDD pfet_03v3 L=2u W=6u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=2
XM9 net1 VbiasN1 VSS VSS nfet_03v3 L=2u W=2u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=2
XM8 Vout VbiasN2 Vcomn VSS nfet_03v3 L=2u W=5u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=1
XM7 Val VbiasN2 net1 VSS nfet_03v3 L=2u W=5u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=1
XM10 Vcomn VbiasN1 VSS VSS nfet_03v3 L=2u W=2u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=2
XM15 VDD VDD VDD VDD pfet_03v3 L=3u W=1u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf
+ * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u
+ / W' sa=0 sb=0 sd=0 m=28
XM16 VDD VDD VDD VDD pfet_03v3 L=1.5u W=1u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) *
+ W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=20
XM13 VSS VSS VSS VSS nfet_03v3 L=3u W=1u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf
+ * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u
+ / W' sa=0 sb=0 sd=0 m=18
XM12 VSS VSS VSS VSS nfet_03v3 L=6.5u W=0.5u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=36
XM14 VSS VSS VSS VSS nfet_03v3 L=1u W=1u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) * W/nf
+ * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u / W' nrs='0.18u
+ / W' sa=0 sb=0 sd=0 m=30
XM1 Vdm6 V- net2 VSS nfet_03v3 L=1u W=10u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) *
+ W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=20
XM2 Vdm5 V+ net2 VSS nfet_03v3 L=1u W=10u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) *
+ W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=20
XM11 net2 VbiasN1 VSS VSS nfet_03v3 L=2u W=2u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=40
.ends


* expanding   symbol:  error_amplifier_bias_N_input.sym # of pins=7
** sym_path: blocks/composite/folded_cascode/designs/gf180/error_amplifier_bias_N_input/xschem/error_amplifier_bias_N_input.sym
** sch_path: blocks/composite/folded_cascode/designs/gf180/error_amplifier_bias_N_input/xschem/error_amplifier_bias_N_input.sch
.subckt error_amplifier_bias_N_input VbiasN1 VbiasN2 VbiasP2 VDD VSS Vref VbiasP1
*.ipin Vref
*.iopin VbiasN1
*.iopin VbiasN2
*.iopin VDD
*.iopin VbiasP2
*.iopin VSS
*.iopin VbiasP1
XM1 VbiasN2 VbiasN2 net2 VSS nfet_03v3 L=6u W=0.5u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=1
XM2 VbiasP1 VbiasP1 VDD VDD pfet_03v3 L=2u W=0.5u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=1
XM3 VbiasP1 Vref net1 VSS nfet_03v3 L=6u W=0.5u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=1
XM4 VbiasN2 VbiasP1 VDD VDD pfet_03v3 L=2u W=0.5u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=1
XM5 VbiasN1 VbiasP1 VDD VDD pfet_03v3 L=2u W=0.5u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=1
XM6 net6 VbiasP2 VDD VDD pfet_03v3 L=2u W=0.5u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=1
XM7 VbiasP2 VbiasP2 net6 VDD pfet_03v3 L=2u W=0.5u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=1
XM8 net7 net8 VDD VDD pfet_03v3 L=2u W=0.5u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=3
XM9 net8 VbiasP2 net7 VDD pfet_03v3 L=2u W=0.5u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=2
XM10 net10 VbiasN1 VSS VSS nfet_03v3 L=6u W=0.5u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=4
XM11 VbiasN1 VbiasN2 net3 VSS nfet_03v3 L=6u W=0.5u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=5
XM12 VbiasP2 VbiasN2 net4 VSS nfet_03v3 L=6u W=0.5u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=5
XM13 net8 VbiasN2 net9 VSS nfet_03v3 L=6u W=0.5u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=5
XM14 net2 VbiasN2 VSS VSS nfet_03v3 L=6u W=0.5u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=1
XM15 net3 VbiasN1 net11 VSS nfet_03v3 L=6u W=0.5u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=4
XM16 net4 VbiasN1 net5 VSS nfet_03v3 L=6u W=0.5u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=4
XM17 net9 VbiasN1 net10 VSS nfet_03v3 L=6u W=0.5u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=4
XM18 net1 Vref VSS VSS nfet_03v3 L=6u W=0.5u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=1
XM19 net5 VbiasN1 VSS VSS nfet_03v3 L=6u W=0.5u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=4
XM20 net11 VbiasN1 VSS VSS nfet_03v3 L=6u W=0.5u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=4
.ends

.GLOBAL GND
.end
